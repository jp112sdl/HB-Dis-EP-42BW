# Repository jp112sdl/HB-Dis-EP-42BW

File README.md:

# HB-Dis-EP-42BW

## Infos
Thread im Homematic-Forum: https://homematic-forum.de/forum/viewtopic.php?f=76&t=48153

## Parts
- ATMega **1284P** (für den [Prototypen](https://github.com/jp112sdl/HB-Dis-EP-42BW/blob/master/Images/IMG_9180.jpg) habe ich die [HM-ES-PWMSw1-Pl_GosundSP1-Platine](https://raw.githubusercontent.com/stan23/HM-ES-PMSw1-Pl_GosundSP1/master/Bilder/Platine_V2_bestückt.jpg) missbraucht ^^)
- 11 Taster (10 Tasterkanäle + 1 Anlerntaster)
- 2 Widerstände 330 Ohm
- 2 LEDs oder 1 Dual-Color-LED
- 4.2" ePaper Display
  - [mit SPI Interface](https://www.exp-tech.de/new/8289/400x300-4.2-e-ink-display-module), passt dann jedoch nicht in die [Frontabdeckung](Images/ePaper-Front.stl) - da ist dann eigene Kreativität gefragt
  - [mit RAW Interface](https://www.exp-tech.de/displays/e-paper-e-ink/8885/waveshare-4.2-e-ink-raw-display-400x300), setzt jedoch noch ein SPI-Treiberboard voraus
    - [Universal e-Paper Raw Panel Driver HAT](https://www.exp-tech.de/displays/e-paper-e-ink/8525/universal-e-paper-raw-panel-driver-hat) oder
    - [CrystalFontz ePaper Adapter Board](https://www.crystalfontz.com/product/cfa10084-epaper-adapter-board)
- 2x 2fach AAA Batteriehalter (werden parallel betrieben; passte am besten ins [Gehäuse](https://github.com/jp112sdl/HB-Dis-EP-42BW/blob/master/Images/IMG_9181.jpg))    

## Arduino
- [MCUDude/MightyCore Board](https://github.com/MCUdude/MightyCore)-Unterstützung für den 1284P
  - Pinout: Standard
  - Clock: 8MHz external
  - BOD: Disabled
  - Compiler LTO: Disabled
  - Variant: 1284P
- Bibliotheken:  
  - [AskSinPP](https://github.com/pa-pa/AskSinPP) (master-Branch verwenden!)
  - [Low-Power](https://github.com/rocketscream/Low-Power)
  - [EnableInterrupt](https://github.com/GreyGnome/EnableInterrupt)
  - [GxEPD](https://github.com/ZinggJM/GxEPD) 
    - :arrow_right: um die Display-Aktualisierungsdauer zu verringern, lohnt es sich, in der `GxGDEW042T2.h` den Wert für [`GxGDEW042T2_PAGES`](https://github.com/ZinggJM/GxEPD/blob/master/src/GxGDEW042T2/GxGDEW042T2.h#L25) auf `3` zu reduzieren
  - [Adafruit-GFX](https://github.com/adafruit/Adafruit-GFX-Library)
  - [U8g2_for_Adafruit_GFX](https://github.com/olikraus/U8g2_for_Adafruit_GFX)

## Gehäuse
### Stand
https://www.thingiverse.com/thing:3331473

### Front
[Front](Images/ePaper-Front.stl)

## KiCad design PCB/HB-Dis-EP-42BW.kicad_pcb

File PCB/README.md:

# HB-Dis-EP-42BW Platine     

# Work in Progress - in Bearbeitung...

# Hardware

### Bauteile

#### Reichelt

[Bestellliste](https://www.reichelt.de/my/1564026) (ohne die optionalen Bauteile)

Bauteil                  | Bestellnummer    | Anzahl | Kommentar
------------------------ | ---------------- | ------ | ---------
C1                       | X5R-G0603 10/6   |   1    | -
C2 .. C5, C7             | X7R-G0603 100N   |   5    | -
C6, C8                   | X7R-G0603 1,0/16 |   2    | -
D1                       | KBT L-115WEGW    |   1    | -
R1, R5                   | RND 0603 1 10K   |   2    | -
R2 .. R3                 | RND 0603 1 330   |   2    | -
R4                       | RND 0603 1 1,0M  |   1    | -
R6                       | RND 0603 1 4,7k  |   1    | optional: für Batteriespannungsmessung unter Last
R7                       | RND 155HP05 CI   |   1    | optional: für Batteriespannungsmessung unter Last
R8                       | RND 155HP05 AF   |   1    | optional: für Batteriespannungsmessung unter Last
Q1                       | IRLML 6344       |   1    | optional: für Batteriespannungsmessung unter Last
SW0                      | TASTER 3301      |   1    | optional: Konfigtaster *Achtung, diese Bauhöhe ist für die Montage kopfüber!*
SW1 .. SW10              | JTP-1130         |  10    | *Achtung, evtl. andere Bauhöhe!*
U1                       | ATMEGA 1284P-AU  |   1    | -
Y1                       | CSTCE 8,00       |   1    | -
Verbinder zum CC1101     | MPE 150-1-010    |   1    | -
Verbinder zum ePaper     | MPE 087-1-010    |   1    | -
Verbinder zur Batterie   | -                |   -    | optional, kann auch angelötet werden
Batteriefach             | HALTER 2XUM4-NLF |   -    | optional, für 2x AAA
Batteriefach             | HALTER 2XAAZ     |   -    | optional, für 2x AA

#### Farnell

Bauteil                  | Bestellnummer    | Anzahl | Kommentar
------------------------ | ---------------- | ------ | ---------
U3                       | [MCP111T-270E/TT](https://de.farnell.com/microchip/mcp111t-270e-tt/ic-supervisor-2-63v-low-sot-23b/dp/1851877)  |   1    | optional, Unterspannungserkennung

#### Sonstiges

Bauteil | Bezeichnung                  | Anzahl | Kommentar
------- | ---------------------------- | ------ | ---------
U2      | CC1101 Funkmodul 868 MHz     |   1    | z.B. [eBay](https://www.ebay.de/itm/272455136087)
Display | 4,2" ePaper mit SPI-Anschluss|   1    | z.B. [EXP-R63-045](https://www.exp-tech.de/new/8289/400x300-4.2-e-ink-display-module)

~8,3 cm Draht als Antenne

### Programmieradapter
- 1x ISP (z.B. [diesen hier](https://www.diamex.de/dxshop/USB-ISP-Programmer-fuer-Atmel-AVR-Rev2))

# Software

### Fuses und Lockbits

Fuse     | Wert | Kommentar
-------- | ---- | ---------
Extended | 0xFF |
High     | 0xD4 |
Low      | 0xFF |
Lockbits | 0xEF | optional

`C:\Program Files (x86)\Arduino\hardware\tools\avr\bin> .\avrdude -C ..\etc\avrdude.conf -p m1284p -P com7 -c stk500 -U lfuse:w:0xFF:m -U hfuse:w:0xD4:m -U efuse:w:0xFF:m`

### Firmware

# Bauanleitung

Zuerst den ATmega auflöten, die Markierung (kleiner Punkt) muss zur Beschriftung U1 zeigen.
Danach den Resonator, die Kondensatoren und Widerstände auflöten.

Mit einem Multimeter messen ob kein Kurzschluss zwischen VCC und GND besteht (mehrere 10 K Widerstand sind okay).

Den ISP Programmieradapter an den 6-poligen Anschluss auf der **Rückseite** anschließen.
Nun kann entweder der Sketch direkt geflasht werden ("Hochladen mit Programmer"), oder zuerst der [Bootloader](https://github.com/TomMajor/AskSinPP_Examples/tree/master/Info/Bootloader/mega1284) und dann der eigentliche Sketch über den FTDI-Anschluss.

Pin am ISP-Kabel | Bedeutung
---------------- | ----------
1                | MISO
2                | VCC
3                | SCK
4                | MOSI
5                | Reset
6                | GND

Anschließend können das Funkmodul, die Taster und die LED eingelötet werden.

An den Antennenanschluss muss noch das 8,3 cm Drahtstück angelötet werden.

Mit einem FTDI USB-seriell-Adapter und einem Terminalprogramm kann man die Ausgabe beobachten. Es sollten schon *Ignore...*-Meldungen empfangen und angezeigt werden.

# ToDo

#### Abstände ePaper zu Platine
#### Höhe der Taster
#### Konfigtaster
Orientierung wie die anderen 10 Taster, oder über Kopf.
#### Ausrichtung LED
#### Abstandsbolzen
#### Befestigung im Gehäuse
#### Batterien 2x AA statt 2x 2x AAA

# Bilder

Dieses Werk ist lizenziert unter einer [Creative Commons Namensnennung - Nicht-kommerziell - Weitergabe unter gleichen Bedingungen 3.0 International Lizenz](http://creativecommons.org/licenses/by-nc-sa/3.0/).

Parts:
C1: 10u; C_0603_HandSoldering
C2, C3, C4, C5, C7: 100n; C_0603_HandSoldering
C6, C8: 1u; C_0603_HandSoldering
D1: LED_Dual; LED_D3.0mm-3
J1: Reset; Testpad
J2: FTDI; Pin_Header_Straight_1x06_Pitch2.54mm
J3: ISP; Pin_Header_Straight_2x03_Pitch2.54mm
J4: ePaper; Waveshare_4.2inch_Module
J5: ePaper_TestPoints; Pin_Header_Straight_1x08_Pitch2.54mm
J6: Supply; Pin_Header_Straight_1x02_Pitch2.54mm
J7: Conn_GPIO; Pin_Header_Straight_1x05_Pitch1.27mm
J8: Config; Pin_Header_Straight_1x02_Pitch2.54mm
J9: Conn_I2C; Pin_Header_Straight_1x04_Pitch1.27mm
Q1: IRLML6344; SOT-23
R1, R5: 10k; R_0603_HandSoldering
R2, R3: 300; R_0603_HandSoldering
R4: 1M; R_0603_HandSoldering
R6: 4k7; R_0603_HandSoldering
R7: 30; R_0603_HandSoldering
R8: 10; R_0603_HandSoldering
SW0, SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: SW_Push; SW_PUSH_6mm
U1: ATMEGA1284P-AU; TQFP-44_10x10mm_Pitch0.8mm_HandSoldering
U2: CC1101; CC1101_Module
U3: MCP111; SOT-23
Y1: Resonator; Resonator_SMD_muRata_TPSKA-3pin_7.9x3.8mm_HandSoldering

Connections:
/BI_EN: Q1.1 (G), R6.1, U1.11 ((PCINT26/RXD1/INT0)PD2)
/BI_MEAS: R7.2, R8.1, U1.37 ((PCINT0/ADC0)PA0)
/BTN1: SW1.1, U1.43 ((PCINT11/AIN1/OC0)PB3)
/BTN2: SW2.1, U1.36 ((PCINT1/ADC1)PA1)
/BTN3: SW3.1, U1.35 ((PCINT2/ADC2)PA2)
/BTN4: SW4.1, U1.34 ((PCINT3/ADC3)PA3)
/BTN5: SW5.1, U1.33 ((PCINT4/ADC4)PA4)
/BTN6: SW6.1, U1.32 ((PCINT5/ADC5)PA5)
/BTN7: SW7.1, U1.31 ((PCINT6/ADC6)PA6)
/BTN8: SW8.1, U1.30 ((PCINT7/ADC7)PA7)
/BTN9: SW9.1, U1.26 ((PCINT23/TOSC2)PC7)
/BTN10: SW10.1, U1.25 ((PCINT22/TOSC1)PC6)
/CONFIG: J8.1, SW0.1, U1.16 ((PCINT31/OC2A)PD7)
/CS: R5.2, U1.44 ((PCINT12/OC0B/~SS~)PB4), U2.8 (CSN)
/DTR: C7.1, J2.1
/GDO0: U1.42 ((PCINT10/AIN0/INT2)PB2), U2.7 (GDO0)
/GPIO1: J7.2, U1.22 ((PCINT19/TMS)PC3)
/GPIO2: J7.3, U1.23 ((PCINT20/TDO)PC4)
/GPIO3: J7.4, U1.24 ((PCINT21/TDI)PC5)
/GxBSY: J4.8, J5.8, U1.12 ((PCINT27/TXD1/INT1)PD3)
/GxCS: J4.5, J5.5, U1.21 ((PCINT18/TCK)PC2)
/GxDC: J4.6, J5.6, U1.13 ((PCINT28/XCK1/OC1B)PD4)
/GxRST: J4.7, J5.7, U1.15 ((PCINT30/OC2B/ICP)PD6)
/LED1: R2.2, U1.40 ((PCINT8/T0/XCK)PB0)
/LED2: R3.2, U1.41 ((PCINT9/CLKO/T1)PB1)
/MISO: J3.1, U1.2 ((PCINT14/MISO)PB6), U2.5 (SO)
/MOSI: J3.4, J4.3, J5.3, U1.1 ((PCINT13/MOSI)PB5), U2.3 (SI)
/RESET: C7.2, J1.1, J3.5, R1.2, U1.4 (~RESET), U3.1 (OUT)
/RX: J2.3, U1.9 ((PCINT24/RXD0)PD0)
/SCK: J3.3, J4.4, J5.4, U1.3 ((PCINT15/SCK)PB7), U2.4 (SCLK)
/SCL: J9.2, U1.19 ((PCINT16/SCL)PC0)
/SDA: J9.3, U1.20 ((PCINT17/SDA)PC1)
/TX: J2.2, U1.10 ((PCINT25/TXD0)PD1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, D1.2 (K), J2.5, J2.6, J3.6, J4.2, J5.2, J6.2, J7.5, J8.2, J9.4, Q1.2 (S), R6.2, SW0.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, U1.6 (GND), U1.18 (GND), U1.28 (GND), U1.39 (GND), U2.2 (GND), U3.2 (GND), Y1.2
unnamed: D1.1 (A1), R2.1
unnamed: D1.3 (A2), R3.1
unnamed: Q1.3 (D), R8.2
unnamed: R4.1, U1.7 (XTAL2), Y1.1
unnamed: R4.2, U1.8 (XTAL1), Y1.3
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, J2.4, J3.2, J4.1, J5.1, J6.1, J7.1, J9.1, R1.1, R5.1, R7.1, U1.5 (VCC), U1.17 (VCC), U1.27 (AVCC), U1.29 (AREF), U1.38 (VCC), U2.1 (VCC), U3.3 (VCC)

Notes on the sheet:
FTDI
1.0
License: CC BY-NC-SA 3.0
Jan. 2019
ePaper
Babbling Idiot Protection: measure battery under load

Board: 2 copper layers, 61.4 x 103.3 mm, 42 parts (10 on the bottom side), 40 nets.

## Code that names these connections

File HB-Dis-EP-42BW.ino (part):

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#include <GxIO/GxIO.h>
#include "U8G2_FONTS_GFX.h"

#define GxRST_PIN  14   // PD6
#define GxBUSY_PIN 11   // PD3
#define GxDC_PIN   12   // PD4
#define GxCS_PIN   18   // PC2

GxIO_Class io(SPI, GxCS_PIN, GxDC_PIN, GxRST_PIN);
GxEPD_Class display(io, GxRST_PIN, GxBUSY_PIN);

U8G2_FONTS_GFX u8g2Fonts(display);
//////////////////////////////////////////////////////////////////////////////
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  #define ASKSIN_PLUS_PLUS_VERSION_STR ASKSIN_PLUS_PLUS_VERSION
#endif

#define CC1101_CS_PIN       4   // PB4
#define CC1101_GDO0_PIN     2   // PB2
#define CC1101_SCK_PIN      7   // PB7
#define CC1101_MOSI_PIN     5   // PB5
#define CC1101_MISO_PIN     6   // PB6
#define CONFIG_BUTTON_PIN  15   // PD7
#define LED_PIN_1           0   // PB0
#define LED_PIN_2           1   // PB1
#define BTN1_PIN            3   // PB3
#define BTN2_PIN           A1   // PA1
#define BTN3_PIN           A2   // PA2
#define BTN4_PIN           A3   // PA3
#define BTN5_PIN           A4   // PA4
#define BTN6_PIN           A5   // PA5
#define BTN7_PIN           A6   // PA6
#define BTN8_PIN           A7   // PA7
#define BTN9_PIN           23   // PC7
#define BTN10_PIN          22   // PC6

#define TEXT_LENGTH        16
#define DISPLAY_LINES      10
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
  DINIT(57600, ASKSIN_PLUS_PLUS_IDENTIFIER);
  sdev.init(hal);
  remoteChannelISR(sdev.remChannel(1),BTN1_PIN);
  remoteChannelISR(sdev.remChannel(2),BTN2_PIN);
  remoteChannelISR(sdev.remChannel(3),BTN3_PIN);
  remoteChannelISR(sdev.remChannel(4),BTN4_PIN);
  remoteChannelISR(sdev.remChannel(5),BTN5_PIN);
  remoteChannelISR(sdev.remChannel(6),BTN6_PIN);
  remoteChannelISR(sdev.remChannel(7),BTN7_PIN);
  remoteChannelISR(sdev.remChannel(8),BTN8_PIN);
  remoteChannelISR(sdev.remChannel(9),BTN9_PIN);
  remoteChannelISR(sdev.remChannel(10),BTN10_PIN);

  buttonISR(cfgBtn, CONFIG_BUTTON_PIN);
  sdev.initDone();
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
## Commit log

2018-12-02 some changes :)
2018-12-03 added images
2018-12-09 Schematic V0.1
2018-12-09 changed images
2018-12-09 - added text alignment functions - some minor improvements
2018-12-15 lots of changes
    - TH buttons
    - footprint of ePaper
    - footprint of adapter board
2018-12-15 initial PCB placement
2018-12-16 routing...
    - moved decoupling caps to bottom side
    - routed most of it
    - looks like the button pins shall be rearranged for better routing
2018-12-16 first board layout done, buttons swapped
    buttons are connected differently to simplify routing
2018-12-16 added opt. 8 MHz resonator
2018-12-20 replace bare ePaper by module
2019-01-01 added more icons
2019-01-05 do not replace chars in source array
2019-01-05 switched to MightyCore Standard Layout
2019-01-05 - added a LED to show that the epaper is workin - added define USE_CC1101_ALT_FREQ_86835 for non freq stable cc1101 - some smaller fixes
2019-01-05 added/deleted some images
2019-01-05 added front stl
2019-01-05 add images
2019-01-05 added some images
2019-01-08 Icon and Text always have to be set together
2019-01-08 improved icon handling when getting new text
2019-01-13 several improvement on PCB
    - 4x GPIO for future use
    - battery measurement under switchable load
    - caps @ CC1101 and @ ePaper changed to 10 uF
    - extra solder points on the way to the ePaper connector
    (option to cut the upper 5 mm to fit the size of the bare ePaper)
    - remove copper layers in top left, to place antenna there
2019-01-17 further improvements to PCB
    - change caps @ CC1101 and @ ePaper to 1 uF
    - shrink GPIOs to 3
    - add I²C connecter for future use
    - move config button to desired place and add hole for optional head-over-heels mounting
    - add 6-pin JTAG header on backside
2019-01-19 added image
2019-01-20 even more improvements on PCB
    - slimmer pads on TQFP44 for easier soldering
    - CC1101 power pads changed to "oval" so that the net is connected horizontal/vertical and not diagonal
    - moved vias out of SMD pads
2019-01-20 replace VCC layer by net
    as suggested by TomMajor
2019-01-29 small PCB improvments
    - enlarge VCC where connected to pads
2019-02-01 last PCB improvements for V1.0
    - put correct mounting holes
2019-02-19 remove binary file
    was accidentally comitted
2019-02-23 change pin definition to match the PCB
    previous pin definition matched Jérôme's flywire setup
2019-02-24 Platinenbeschreibung
2019-02-24 disallow multiple includes
2019-02-24 add destructor
2019-02-24 no changes, only code refactoring
2019-02-28 updated BOM and ordering information
2019-02-28 more details about the assembly
2019-03-01 update resistor values for BI and LED
2019-03-03 minor change: replaced 'drawExampleBitmap' with 'drawBitmap'
2019-03-10 small updates in readme
2019-03-10 PCB V1.1
    - fix spacing and placement of buttons (8.5 mm instead of 9.0 mm)
    - add hole for CC1101 antenna
    - move battery connector a bit
2019-03-10 PCB V1.1 3D pics
2019-03-15 Update HB-Dis-EP-42BW.kicad_pcb
    - move config button to bottom of pcb
    - fix some 3D symbols
2019-03-16 update 3D pics
2019-03-26 - allow fixtext in dynamic texts - clear line with 0xfe
2019-03-26 added 2 new icons; calendar and thermometer
2019-03-26 allow icon to be placed left or right to the text, when alignment is center
2019-03-26 Trim fixtexts
2019-03-27 check range for valid fix text number
2019-03-29 update start screen
    - show compile date (useful to know how old the SW is)
    - adjust box around the text
2019-04-02 burst detector is not longer needed
2019-04-10 non-functional changes; code refactoring
2019-04-16 use separate register for display inverting and ledmode add lowbat value in list0
2019-04-16 use LibSPI
2019-04-19 add epaper refresh delay code refactoring
2019-04-21 introduce ePaperType class use RemoteChannel for buttons
2019-04-21 refactoring
2019-04-22 replaced images
2019-04-22 fixed compile error
2019-04-23 add battery icon
2019-04-23 implemented new device model for use with mains (no burst needed)
2019-04-23 send batt low in ack message of actioncommand and some minor improvements
2019-04-23 added some new icons
2019-04-23 changed image
2019-04-24 more plausibility checks
2019-04-24 renamed variable check for msgBuffer overflow
2019-04-24 changed debug message
2019-04-25 plausibility check for icon
2019-04-25 use ePaperWorkingLed in ePaper class show init screen only when there is no master paired moved some functions
2019-04-25 use epaper workingLed only private
2019-04-26 check if icon number is in range
2019-05-03 fixed min length
2019-05-03 moved ePaper Working LED into ePaperType class
2019-05-04 Show page size on init screen
2019-05-05 new initscreen
2019-05-05 use dedicated channels for remote buttons and ActionCommandMsg
2019-06-03 Add support for text x position with ScriptHelper
2019-06-18 don't sleep while epaper alarm is active
2019-06-18 renamed 'working' to 'waiting'
2019-07-02 to use b/w/r display uncomment // #define USE_COLOR add 0x04 to TEXT_KEY to make text colored (0x16 instead of 0x12) add 0x04 to ICON_KEY to make icon colored (0x17 instead of 0x13)
2019-07-02 send short/long key press on startup to trigger ccu
2019-07-02 reset button state to none
2019-07-02 use stable savePower method
2019-07-02 add image
2019-07-03 Don't sleep while updating display, tested version
2019-07-03 don't trim() here... maybe we want a space as first or last char
2019-07-03 no extra variable - value is only used once
2019-07-05 set critical bat via webui show battery empty symbol on display
2019-07-06 update code
2019-07-16 removed double include
2019-10-03 Add support for Script_Helper xpos color feature
2020-07-19 add outOfHouseDisplay
2020-07-21 next try :)
2021-01-13 Update HB-Dis-EP-42BW.ino
    make compatible with v5.0.0
2021-01-13 Update HB-Dis-EP-42BW.ino
    real fix for v5.0.0
2021-04-11 add placement overview, by dirk.abel

Notices in the files:
HB-Dis-EP-42BW.ino:
2016-10-31 papa Creative Commons - http://creativecommons.org/licenses/by-nc-sa/3.0/de
2018-12-01 jp112sdl Creative Commons - http://creativecommons.org/licenses/by-nc-sa/3.0/de
PCB/README.md:
Creative Commons Lizenzvertrag
